## drivers/misc/hwid/Kconfig
```kconfig
config MI_HARDWARE_ID
	tristate "Register hwid interface"
	default n
	help
	  This adds support for mi-project type and adc values read.
```
